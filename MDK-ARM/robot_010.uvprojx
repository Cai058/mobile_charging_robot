# Keil uVision project robot_010.uvprojx, settings and files
target robot_010 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: new_robo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\BSP;..\BSP\inc;..\BSP\src;..\User;..\User\Inc;..\Controller;..\Controller\inc;..\Entity;..\Entity\src;..\Entity\inc;..\math;..\math\inc;..\math\src;..\User\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../User/Src/: main.c can.c gpio.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart_callback.c Robot_Config.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../User/Src/: system_stm32f4xx.c
  group BSP
    ../BSP/src/: bsp_can.c bsp_key.c bsp_L298N.c bsp_led.c bsp_limitSwitch.c bsp_photogate.c bsp_ultrawave.c pid.c time.c bsp_debug_usart.c cJSON.c bsp_rgb.c bsp_rc.c bsp_485_battery.c bsp_485_rfid.c bsp_485_server.c
  group Controller
    ../Controller/src/: ControllerDummy.c Chassiscontroller.c ControllerRC.c
  group Entity
    ../Entity/src/: Battery.c RC.c RFID.c Server.c
  group math
    ../math/src/: first_order_filter.c
software components: CMSIS:CORE 4.3.0
